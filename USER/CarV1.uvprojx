# Keil uVision project CarV1.uvprojx, settings and files
target Car_Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CarV1.0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\CMSIS;..\FWLIB\inc;..\USER;..\HARDWARE\Task_Board;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\Core_Board;..\HARDWARE\CAN;..\my_lib;..\SYSTEM\timer;..\HARDWARE\Drive;..\HARDWARE\Function;..\HARDWARE\Zigbee;..\HARDWARE\NEW_Task_board;..\Voluntarily;..\HARDWARE\NEW_SYN;..\HARDWARE\RNG;..\HARDWARE\Card;..\HARDWARE\crc;..\NEWDEF\MasterCar;..\NEWDEF\PID;..\NEWDEF\Flag;..\NEWDEF\RFIDCard;..\NEWDEF\WiFi;..\NEWDEF\MyString;..\NEWDEF\TaskBoard
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/Task_Board/: infrared.c ultrasonic.c bh1750.c syn7318.c bkrc_voice.c
    ../HARDWARE/Core_Board/: cba.c usart.c power_check.c uart_a72.c uart_drv.c rc522.c
    ../HARDWARE/Drive/: drive.c agv.c
    ../HARDWARE/RNG/: rng.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/timer/: Timer.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_rng.c stm32f4xx_syscfg.c
  group CMSIS
    ../CMSIS/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group my_lib
    ../my_lib/: my_lib.c data_base.c roadway_check.c data_filtering.c
  group CAN
    ../HARDWARE/CAN/: can_drv.c CanP_HostCom.c fifo_drv.c Hard_Can.c can_user.c Can_check.c
  group refer code
    ../HARDWARE/Zigbee/: Zigbee.c
    ../HARDWARE/Function/: Function.c
    ../HARDWARE/NEW_Task_board/: NEW_Task_board.c
    ../Voluntarily/: Voluntarily.c
    ../HARDWARE/Card/: Card.c
    ../HARDWARE/crc/: CRC.C
    ../TXT/: TXT.txt
  group NEWDEF
    ../NEWDEF/MasterCar/: MasterCarCotrol.c
    ../NEWDEF/PID/: PID.c
    ../NEWDEF/Flag/: OperationFlag.c
    ../NEWDEF/RFIDCard/: RFIDCARD.c
    ../NEWDEF/WiFi/: OperationWiFi.c
    ../NEWDEF/MyString/: MyString.c
    ../NEWDEF/TaskBoard/: TaskBoard.c
    ../NEWDEF/: test.c
